# IAR project SCT_430.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: C:\Users\Administrator\Desktop\MSP430_UPDATE\SCT_430_BOOT\code\app\inc; C:\Users\Administrator\Desktop\MSP430_UPDATE\SCT_430_BOOT\code\app\src; C:\Users\Administrator\Desktop\MSP430_UPDATE\SCT_430_BOOT\code\bsp\inc; C:\Users\Administrator\Desktop\MSP430_UPDATE\SCT_430_BOOT\code\bsp\src; C:\Users\Administrator\Desktop\MSP430_UPDATE\SCT_430_BOOT\code\drv\inc; C:\Users\Administrator\Desktop\MSP430_UPDATE\SCT_430_BOOT\code\drv\src; C:\Users\Administrator\Desktop\MSP430_UPDATE\SCT_430_BOOT\code\sys\include; C:\Users\Administrator\Desktop\MSP430_UPDATE\SCT_430_BOOT\code\sys; C:\Users\Administrator\Desktop\MSP430_UPDATE\SCT_430_BOOT\code\test; C:\Users\Administrator\Desktop\MSP430_UPDATE\SCT_430_BOOT\code\user
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f149.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group app
    ../code/app/src/: Boot.c DTprotocol.c LoopRamFunc.c
  group bsp
    ../code/bsp/src/: msp430f149_flash.c msp430f149_gpio.c msp430f149_uart.c msp430f149_wdt.c
  group drv
    ../code/drv/src/: Power.c
  group sys
    ../code/sys/: kernel.c
  group user
    ../code/user/: main.c
